# Keil uVision project BH-STM32.uvprojx, settings and files
target NKP-LJ-05B_APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NKP-LJ-05B_APP +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\..\output\LJ-05B_20241030APP.bin ..\..\output\NKP-LJ-05B_APP.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,__STRICT_ANSI__
  c include: ..\..\App_Common;..\..\App_Modbus;..\..\Drv_Common;..\..\Drv_Modbus;..\..\Arm;..\..\Libraries;..\..\Libraries\FWlib\inc;..\..\Mid_Modbus;..\..\Mid_Modbus\rtu;..\..\Mid_Modbus\include;..\..\Rtt_Segger
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App_Common
    ../../App_Common/: main.c store_app.c sensor_app.c surge_history.c picture.c invalid_app.c mov_invalid.c hmi_app2.c hmi_mainpage.c hmi_surge_history.c hmi_invalid_history.c hmi_common.c hmi_serialwork.c
  group App_Modbus
    ../../App_Modbus/: modbus_app.c
  group Mid_Modbus
    ../../Mid_Modbus/: mb.c modbus_slave.c
    ../../Mid_Modbus/functions/: mbfuncdisc.c mbfuncholding.c mbutils.c
    ../../Mid_Modbus/rtu/: mbcrc.c mbrtu.c
  group Drv_Common
    ../../Drv_Common/: stm32f10x_it.c systick_drv.c delay.c led_drv.c eeprom_drv.c key_drv.c rtc_drv.c iap_drv.c norflash_drv.c lcd12864_drv.c switch_drv.c sensor_drv.c ntc_drv.c surgemdl_drv.c iwdg_drv.c
  group Drv_Modbus
    ../../Drv_Modbus/: portevent.c portserial.c porttimer.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Arm
    ../../Arm/: system_stm32f10x.c startup_stm32f10x_hd.s
  group Doc
    ../../Doc/: readme.txt
  group RTT_Segger
    ../../Rtt_Segger/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: Compiler:I/O:STDERR 1.2.0
